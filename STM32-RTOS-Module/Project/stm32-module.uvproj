# Keil uVision project stm32-module.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-module +hex
  AfterMake: fromelf.exe  --bin  --output  .\OUTPUT\stm32-module.bin   .\OUTPUT\stm32-module.axf
  c flags: Optim=3 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\lib\inc;..\CMSIS;..\SYSTEM\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\USER\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startcode
    ../startcode/: startup_stm32f10x_md.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/src/: gpio.c stmflash.c sys.c timer.c usart.c wdg.c adc.c delay.c
  group USER
    ../USER/: main.c stm32f10x_it.c GW.c
    ../USER/OLED/: OLED.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
